Commit message: Add files via upload

File: description/robot.urdf (robot description, URDF)
Before this commit: robot robot, 3 links, 2 joints
Links:
- link base_link: geometry collision box size=0.17 0.14 0.145; visual box size=0.17 0.14 0.145
